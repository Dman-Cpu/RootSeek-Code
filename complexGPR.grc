options:
  parameters:
    generate_options: qt_gui
    id: complexGPR
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.000010'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '30'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: '4000000'
    sensitivity: '200000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, 2,  3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30)
  states: {}
- name: blocks_vector_to_stream_3
  id: blocks_vector_to_stream
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_stream_3_0
  id: blocks_vector_to_stream
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_stream_3_0_0
  id: blocks_vector_to_stream
  parameters:
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '32000000'
    fc: '0'
    fftsize: '1024'
    rate: '10000000000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '32000000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '32000000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '32000000'
    type: float
  states: {}
- name: uhd_fpga_fft_0
  id: uhd_fpga_fft
  parameters: {}
  states: {}
- name: uhd_fpga_fft_0_0
  id: uhd_fpga_fft
  parameters: {}
  states: {}
- name: uhd_fpga_fft_0_1
  id: uhd_fpga_fft
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '500000000'
    gain0: '0.5'
    gain_type0: normalized
    samp_rate: '32000000'
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '500000000'
    gain0: '1'
    gain_type0: normalized
    samp_rate: '32000000'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_stream_to_vector_0, '0', uhd_fpga_fft_0, port0]
- [blocks_stream_to_vector_1, '0', uhd_fpga_fft_0_0, port0]
- [blocks_stream_to_vector_2, '0', uhd_fpga_fft_0_1, port0]
- [blocks_vco_f_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vco_f_0, '0', blocks_float_to_complex_0, '1']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_to_stream_3, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_to_stream_3_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_vector_to_stream_3_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_fpga_fft_0, port0, blocks_vector_to_stream_3, '0']
- [uhd_fpga_fft_0_0, port0, blocks_vector_to_stream_3_0, '0']
- [uhd_fpga_fft_0_1, port0, blocks_vector_to_stream_3_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
